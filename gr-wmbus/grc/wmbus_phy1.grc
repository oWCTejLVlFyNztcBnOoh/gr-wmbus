<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>wmbus_phy1</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>gr_complex_to_mag_squared</key>
<param><key>id</key><value>gr_complex_to_mag_squared_0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1600000</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>gr_nlog10_ff</key>
<param><key>id</key><value>gr_nlog10_ff_0</value></param>
<param><key>n</key><value>10</value></param>
<param><key>k</key><value>0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_per_sym</value></param>
<param><key>value</key><value>16</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>verbose</value></param>
<param><key>value</key><value>0</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>any_sink</key>
<param><key>id</key><value>any_sink_0_1</value></param>
<param><key>block_desc</key><value>framer</value></param>
<param><key>block_maker</key><value>mbus.framer(msgq, verbose) </value></param>
<param><key>num_inputs</key><value>2</value></param>
</block>
<block>
<key>any_sink</key>
<param><key>id</key><value>any_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>block_desc</key><value>print_char</value></param>
<param><key>block_maker</key><value>baz.print_char()</value></param>
<param><key>num_inputs</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>msgq</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq_error</value></param>
<param><key>value</key><value>-0.0025000</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0</value></param>
<param><key>type</key><value>fff</value></param>
<param><key>decim</key><value>samp_per_sym</value></param>
<param><key>taps</key><value>16*[1./16]</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>wmbus_demod</key>
<param><key>id</key><value>wmbus_demod_0</value></param>
<param><key>samp_rate</key><value>1600000</value></param>
<param><key>samp_per_sym</key><value>16</value></param>
<param><key>freq_error</key><value>-0.0025000</value></param>
</block>
<block>
<key>any</key>
<param><key>id</key><value>any_0</value></param>
<param><key>block_desc</key><value>correlate_preamble</value></param>
<param><key>block_maker</key><value>mbus.correlate_preamble()</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>num_outputs</key><value>1</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import wmbus_blocks as mbus  </value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>import</key><value>import baz</value></param>
</block>
<connection><source_block_id>any_0</source_block_id><sink_block_id>any_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_complex_to_mag_squared_0</source_block_id><sink_block_id>gr_nlog10_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_nlog10_ff_0</source_block_id><sink_block_id>fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>any_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>gr_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>any_0</source_block_id><sink_block_id>any_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>wmbus_demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wmbus_demod_0</source_block_id><sink_block_id>any_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
